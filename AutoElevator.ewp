# IAR project AutoElevator.ewp, settings and files
configuration master (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; __ENABLE_TRACE; __MASTER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: common; os\include; os\portable\cm3; platform\cm3; platform\stm32f10x\inc; board; D:\project\AutoElevator\board\sensor
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AutoElevator_Master.hex
  ILINK.IlinkOutputFile: AutoElevator.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration expand (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: __DEBUG; __ENABLE_TRACE; __EXPAND
  OBJCOPY.OOCOutputFile: AutoElevator_Expand.hex
  group board
    board/: altimeter.c altimeter.h altimeter_calc.c altimeter_calc.h application.c application.h bluetooth.c bluetooth.h board.c board.h boardmap.c boardmap.h config.h crc.c crc.h dbgserial.c dbgserial.h delay.c delay.h diagnosis.c diagnosis.h elevator.c elevator.h expand.c expand.h floormap.c floormap.h fm24cl64.c fm24cl64.h FreeRTOSConfig.h global.h i2c_software.c i2c_software.h keyctl.c keyctl.h led_monitor.c led_monitor.h led_status.c led_status.h license.c license.h main.c parameter.c parameter.h pinconfig.c pinconfig.h protocol.c protocol.h protocol_expand.c protocol_expand.h protocol_param.c protocol_param.h protocol_robot.c protocol_robot.h relay.c relay.h robot.c robot.h serial.c serial.h stm32f10x_cfg.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_vector.c switch_monitor.c switch_monitor.h
  group common
    common/: assert.h macros.h trace.h types.h
  group os
    os/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group os/include
    os/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group os/portable/cm3
    os/portable/cm3/: heap_2.c port.c port.h portasm.s portmacro.h
  group platform/cm3
    platform/cm3/: cm3_core.h cm3_core.s
  group platform/stm32f10x/inc
    platform/stm32f10x/inc/: stm32f10x_can.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_it.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_rcc.h stm32f10x_scb.h stm32f10x_sig.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_usart.h
  group platform/stm32f10x/src
    platform/stm32f10x/src/: stm32f10x_can.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_scb.c stm32f10x_sig.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
