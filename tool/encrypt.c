#include <stdio.h>
#include <stdlib.h>
#include <stdint.h>
#include <stdbool.h>
#include <string.h>


/* crc map */
static const uint8_t map_high[] =
{
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40
};

static const uint8_t map_low[] =
{
    0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06, 0x07, 0xC7,
    0x05, 0xC5, 0xC4, 0x04, 0xCC, 0x0C, 0x0D, 0xCD, 0x0F, 0xCF, 0xCE, 0x0E,
    0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09, 0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9,
    0x1B, 0xDB, 0xDA, 0x1A, 0x1E, 0xDE, 0xDF, 0x1F, 0xDD, 0x1D, 0x1C, 0xDC,
    0x14, 0xD4, 0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,
    0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3, 0xF2, 0x32,
    0x36, 0xF6, 0xF7, 0x37, 0xF5, 0x35, 0x34, 0xF4, 0x3C, 0xFC, 0xFD, 0x3D,
    0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A, 0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38,
    0x28, 0xE8, 0xE9, 0x29, 0xEB, 0x2B, 0x2A, 0xEA, 0xEE, 0x2E, 0x2F, 0xEF,
    0x2D, 0xED, 0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,
    0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60, 0x61, 0xA1,
    0x63, 0xA3, 0xA2, 0x62, 0x66, 0xA6, 0xA7, 0x67, 0xA5, 0x65, 0x64, 0xA4,
    0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F, 0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB,
    0x69, 0xA9, 0xA8, 0x68, 0x78, 0xB8, 0xB9, 0x79, 0xBB, 0x7B, 0x7A, 0xBA,
    0xBE, 0x7E, 0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,
    0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71, 0x70, 0xB0,
    0x50, 0x90, 0x91, 0x51, 0x93, 0x53, 0x52, 0x92, 0x96, 0x56, 0x57, 0x97,
    0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C, 0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E,
    0x5A, 0x9A, 0x9B, 0x5B, 0x99, 0x59, 0x58, 0x98, 0x88, 0x48, 0x49, 0x89,
    0x4B, 0x8B, 0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,
    0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42, 0x43, 0x83,
    0x41, 0x81, 0x80, 0x40
};

/**
 * @brief calculate crc16 value
 * @param data - data to calculate
 * @param len - data length
 * @return calculated value
 */
uint16_t crc16(const uint8_t *data, uint8_t len)
{
    uint8_t high = 0xFF;
    uint8_t low = 0xFF;
    int index;

    while (len--)
    {
        index = low ^ *(data++);
        low = (uint16_t)(high ^ map_high[index]);
        high = map_low[index];
    }

    return (uint16_t)(high << 8 | low);
}

static void dump_value(const char *title, const uint8_t *data, uint32_t len)
{
    printf("%s = %02x", title, data[0]);
    for (uint32_t i = 1; i < len; ++i)
    {
        printf(" %02x", data[i]);
    }

    printf("\r\n");
}

#define KEY_LEN      16
/** 8 bytes time and 2 bytes validate(key[9],key[4],key[12],key[2],key[5],key[15],key[10],key[13]) */
#define TIME_LEN     10
/** use chip id as key */
uint8_t default_random[] = {0xde, 0xad, 0xbe, 0xef};
uint8_t random_key = 0xae;
uint8_t key[KEY_LEN];

/**
 * @brief reorder data
 * @param data - data to reorder
 */
static void reorder_data(uint8_t *data, uint32_t data_len)
{
    /** out-of-order key, odd-evev, even-odd */
    uint8_t temp = 0;
    for (uint8_t i = 0; i < data_len / 2; ++i)
    {
        temp = data[i];
        if (0 != ((i + 1) % 2))
        {
            data[i] = data[i + data_len / 2 + 1];
            data[i + data_len / 2 + 1] = temp;
        }
        else
        {
            data[i] = data[i + data_len / 2 - 1];
            data[i + data_len / 2 - 1] = temp;
        }
    }
}

/**
 * @brief convert serial number to key
 * @param pserial - serial number
 * @param pkey - converted key
 */
static void serial_number_to_key(const uint8_t *pserial, uint8_t *pkey)
{
    /** fill key with serial_number */
    for (uint8_t i = 0; i < KEY_LEN; ++i)
    {
        pkey[i] = pserial[i];
    }

    reorder_data(pkey, KEY_LEN);

    /** xor random to show key[13] */
    pkey[14] ^= random_key;

    /** use key[13] to xor key */
    for (uint8_t i = 0; i < KEY_LEN; ++i)
    {
        if (14 != i)
        {
            pkey[i] ^= pkey[14];
        }
    }
}

/**
 * @brief encrypt time
 * @param time - time value to encrypt
 * @param pserial - serial number
 * @param pencrypt_time - encrypted time
 */
void encrypt_time(uint32_t time, const uint8_t *pserial, uint8_t *pencrypt_time)
{
    *(uint32_t *)pencrypt_time = time;
    uint8_t temp_key[KEY_LEN];
    serial_number_to_key(pserial, temp_key);

    /** fill encrypt key */
    for (uint8_t i = 0; i < 4; ++i)
    {
        for (uint8_t j = 0; j < KEY_LEN; ++j)
        {
            if (j != i)
            {
                pencrypt_time[i] ^= temp_key[j];
            }
        }
    }

    uint8_t sum = 0;
    for (uint8_t i = 0; i < 4; ++i)
    {
        sum += pencrypt_time[i];
    }

    /** add key verify data */
    for (uint8_t i = 4; i < KEY_LEN; ++i)
    {
        pencrypt_time[i] = crc16(temp_key, KEY_LEN - i);

        /** encrypt verify data */
        pencrypt_time[i] ^= sum;
    }

    reorder_data(pencrypt_time, KEY_LEN);
}

/**
 * @brief decrypt time
 * @param pencryt_time - time need to decrypt
 * @param pserial - serial number
 * @param ptime - decrypted time
 * @param decrypt status
 */
bool decrypt_time(const uint8_t *pencrypt_time, const uint8_t *pserial, uint32_t *ptime)
{

    uint8_t encrypt_time[KEY_LEN];
    for (uint8_t i = 0; i < KEY_LEN; ++i)
    {
        encrypt_time[i] = pencrypt_time[i];
    }

    uint8_t temp_key[KEY_LEN];
    serial_number_to_key(pserial, temp_key);

    reorder_data(encrypt_time, KEY_LEN);

    uint8_t sum = 0;
    for (uint8_t i = 0; i < 4; ++i)
    {
        sum += encrypt_time[i];
    }

    /** verify key */
    uint8_t crc = 0;
    for (uint8_t i = 4; i < KEY_LEN; ++i)
    {
        /** decrypt verify data */
        encrypt_time[i] ^= sum;

        if (encrypt_time[i] != (crc16(temp_key, KEY_LEN - i) & 0xff))
        {
            return false;
        }
    }

    for (uint8_t i = 0; i < 4; ++i)
    {
        for (uint8_t j = 0; j < KEY_LEN; ++j)
        {
            if (j != i)
            {
                encrypt_time[i] ^= temp_key[j];
            }
        }
    }

    *ptime = *((uint32_t *)encrypt_time);

    return true;
}

int main(int argc, char **argv)
{
    if (argc >= 3)
    {
        uint8_t license[KEY_LEN];
        uint8_t serial_number[KEY_LEN];
        memset(serial_number, 0, KEY_LEN);
        uint32_t time = 0;
        /** get serial number */
        for (uint8_t i = 0; i < KEY_LEN * 2; ++i)
        {
            serial_number[i / 2] <<= 4;
            if ((argv[1][i] >= '0') && (argv[1][i] <= '9'))
            {
                serial_number[i / 2] |= argv[1][i] - '0';
            }
            else
            {
                serial_number[i / 2] |= argv[1][i] - 'a' + 10;
            }

        }

        /** get time */
        uint8_t time_len = strlen(argv[2]);
        for (uint8_t i = 0; i < time_len; ++i)
        {
            time <<= 4;
            if ((argv[2][i] >= '0') && (argv[2][i] <= '9'))
            {
                time |= argv[2][i] - '0';
            }
            else
            {
                time |= argv[2][i] - 'a' + 10;
            }
        }

        /** encrypt time */
        encrypt_time(time, serial_number, license);

        dump_value("serial = ", serial_number, KEY_LEN);
        printf("time = 0x%x\r\n", time);
        dump_value("license = ", license, KEY_LEN);
    }
    else
    {
        printf("please input serial number and time!\r\n");
    }

    return 0;
}
